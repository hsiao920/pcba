# Repository hsiao920/pcba (continued)

## KiCad design xt/KunLun_V1.5/KunLun_V1.5.kicad_pcb (continued)

Parts:
C1700, C9895, C9896: 100nF; C0201
D1700, D1701: ESD5471X; ESD0402
R1700, R1702: 2K; R0402
R1802, R1803: 2.2K; R0402
TP1700, TP1701, TP1702: TP_1R00
U1000: RV1126_RV1109; BGA409_14R00X14R00X0R90

Connections:
/P08 17.RV1126/1109_VideoOutput Interface/DEBUG_RX: D1701.1, R1702.2, TP1701.1
/P08 17.RV1126/1109_VideoOutput Interface/DEBUG_TX: D1700.1, R1700.2, TP1700.1
/P08 17.RV1126/1109_VideoOutput Interface/UART2_RX: R1702.1, U1000.H16 (A7_JTAG_TMS_M1 UART2_RX_M1 GPIO3_A3_u)
/P08 17.RV1126/1109_VideoOutput Interface/UART2_TX: R1700.1, U1000.G18 (A7_JTAG_TCK_M1 UART2_TX_M1 GPIO3_A2_u)
CTP_INT: U1000.F20 (I2S1_LRCK_M2 RGMII_TXCLK_M1 CIF_CLKIN_M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); also elsewhere on the board
CTP_RST: U1000.F21 (I2S1_SCLK_M2 RGMII_TXD2_M1 CIF_CLKOUT_M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); also elsewhere on the board
CW_LED_PWM: U1000.H17 (I2C3_SDA_M1 PWM10_M1 SPI1_CLK_M2 LCDC_H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); also elsewhere on the board
GND: C1700.2, C9895.2, C9896.2, D1700.2, D1701.2, TP1702.1; also elsewhere on the board
HALL_OUT_CPU: U1000.M21 (UART4_TX_M1 PWM5_M1 RGMII_COL_M1 CIF_D2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); also elsewhere on the board
I2C4_SCL_M0: R1802.1, U1000.E20 (I2C4_SCL_M0 CAN_RXD_M0 UART3_TX_M2 PWM7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); also elsewhere on the board
I2C4_SDA_M0: R1803.1, U1000.E19 (I2C4_SDA_M0 CAN_TXD_M0 UART3_RX_M2 PWM1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); also elsewhere on the board
LCD_EN: U1000.F19 (I2S1_SDI_M2 RGMII_RXCLK_M1 CIF_HSYNC_M1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)
L_MOTOR_CTR: U1000.L17 (I2C5_SCL_M0 UART4_CTSN_M1 RGMII_CRS_M1 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); also elsewhere on the board
MIPI_DSI_TX0_CLKN: U1000.C18 (MIPI_DSI_TX0_CLKN); also elsewhere on the board
MIPI_DSI_TX0_CLKP: U1000.C19 (MIPI_DSI_TX0_CLKP); also elsewhere on the board
MIPI_DSI_TX0_D0N: U1000.B19 (MIPI_DSI_TX0_D0N); also elsewhere on the board
MIPI_DSI_TX0_D0P: U1000.A19 (MIPI_DSI_TX0_D0P); also elsewhere on the board
PWM_LCD: U1000.D21 (UART3_CTSN_M2 PWM8_M1 SPI1_MISO_M2 LCDC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); also elsewhere on the board
TOUCH_OUT: U1000.J18 (UART4_RTSN_M1 RGMII_TXD3_M1 CIF_D0_M1 L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); also elsewhere on the board
UV_LED_PWM: U1000.C21 (UART3_RTSN_M2 PWM9_M1 SPI1_MOSI_M2 LCDC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); also elsewhere on the board
VCC_0V8: C9896.1, U1000.E18 (MIPI_DSI_TX0_AVDD_0V8); also elsewhere on the board
VCC_1V8: C9895.1, U1000.G15 (MIPI_DSI_TX0_AVDD_1V8); also elsewhere on the board
VCC_3V3: C1700.1, R1802.2, R1803.2, U1000.J15 (VCCIO5_VDD1), U1000.K15 (VCCIO5_VDD2); also elsewhere on the board
WW_LED_PWM: U1000.J17 (I2C3_SCL_M1 PWM6_M1 SPI1_CS0n_M2 LCDC_D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); also elsewhere on the board

Notes on the sheet:
LCDC/RGMII/PWM
MIPI-DSI Interface
UART DEBUG
BT1120 TX
DATA:LCDC_DATA[15:0]
Y[0:7]:LCDC_DATA[8:15]
Cb[0:7]:LCDC_DATA[0:7]
CLOCK:LCDC_CLK
6bit Serial RGB
DATA:LCDC_DATA[5:0]
HSYNC:LCDC_HSYNC
VSYNC:LCDC_VSYNC
DE:LCDC_DEN
8bit Serial RGB
DATA:LCDC_DATA[7:0]
16bit Parallel RGB(RGB656)
R[4:0]:LCDC_DATA[15:11]
B[4:0]:LCDC_DATA[4:0]
G[5:0]:LCDC_DATA[10:5]
18bit Parallel RGB(RGB666)
R[5:0]:LCDC_DATA[17:12]
B[5:0]:LCDC_DATA[5:0]
G[5:0]:LCDC_DATA[11:6]
24bit Parallel RGB(RGB888)
R[7:0]:LCDC_DATA[23:16]
B[7:0]:LCDC_DATA[7:0]
G[7:0]:LCDC_DATA[15:8]
NOTE:
1. If the MIPI_DSI function is't used,
the power supply can be delected.
WAKE_GPIODET must use GPIO3_A0.
The power domain configuration of GPIO should match the actual power supply.
All the power filter capacitors should be placed close to the power pins of SOC.
LCDC/RGMII/CIF/UART/JTAG/I2S/SPI/I2C
MIPI DSI TX0
R0402

Schematic: p09.kicad_sch, 18.RV1126/1109_Audio

Parts:
C1800: 100nF; C0201
U1000: RV1126_RV1109; BGA409_14R00X14R00X0R90

Connections:
GND: C1800.2; also elsewhere on the board
VCC_3V3: C1800.1, U1000.T12 (VCCIO7_VDD); also elsewhere on the board

Notes on the sheet:
Audio Interface
NOTE:
The power domain configuration of GPIO should match the actual power supply.
All the power filter capacitors should be placed close to the power pins of SOC.
I2S/PDM/ACODEC/I2C

Schematic: p10.kicad_sch, 23.Discrete Power for System

Parts:
C2300, C2311: 1uF; C0402
C2301: 22pF; C0402
C2302, C2312, C2321, C2329: 4.7uF; C0402
C2303, C2315, C2335, C2351: 10uF; C0603
C2304, C2305, C2316, C2336, C2350, C2355: 22uF; C0603
C2306, C2317, C2323, C2325, C2331, C2333, C2340, C2356: 100nF; C0402
C2309, C2322, C2328, C2344, C2354: 100pF; C0402
C2310, C2324, C2353: 10nF; C0402
C2314, C2337, C2338, C2342, C2352: 100nF; C0402; not fitted
C2319: 220pF; C0402
C2320, C2330: 10uF; C0402
ED2300: ESD5451N; ESD0402
L2300, L2302, L2303, L2304, L2305: 2.2uH; IND_252010
L2301: 1.0uH; IND_252010
R2301, R2310, R2319, R2321, R2355: 10K; R0402
R2303, R2313, R2336, R2359: 100R; R0402
R2304: 510K; R0402
R2305: 9.1K; R0402
R2306, R2315, R2358: 36K; R0402
R2307: 27K; R0402
R2308: 110K; R0402
R2309, R2318, R2343, R2357: 100K; R0402
R2314: 11K; R0402
R2316, R2353: 24K; R0402
R2317: 130K; R0402
R2320, R2326, R2328: 150K; R0402
R2322, R2340: 33K; R0402
R2325, R2350: 43K; R0402
R2347, R2348, R2349, R2352: 0R; R0402
R2351: 22R; R0402
R2354: 12K; R0402
R2356: 330K; R0402
TP4025, TP4026: TP; TP_1R00
TP4028, TP4029, TP4030, TP4031, TP4032, TP4033, TP4034, TP4035, TP4040: TP; TP_1R00D
U2300: LP3983SAB5F-08; SOT_23_5
U2301, U2304, U2305, U2308, U2310: SY8089A1AAC; SOT_23_5
U2302: WL2808E18-5/TR; SOT_23_5
U2303: ETA3448; SOT_23_5
U2306: SGM809B; SOT_23

Connections:
ARM_PWM0_M0: R2305.2, R2307.1; also elsewhere on the board
GND: C2300.2, C2302.2, C2303.2, C2304.2, C2305.2, C2306.2, C2310.2, C2311.2, C2312.2, C2314.2, C2315.2, C2316.2, C2317.2, C2320.2, C2321.2, C2323.2, C2324.2, C2325.2, C2329.2, C2330.2, C2331.2, C2333.2, C2335.2, C2336.2, C2337.2, C2338.2, C2340.2, C2342.2, C2350.2, C2351.2, C2352.2, C2353.2, C2355.2, C2356.2, ED2300.2, R2304.2, R2309.2, R2310.2, R2318.2, R2321.2, R2322.2, R2328.2, R2343.2, R2355.2, R2357.2, TP4026.1, TP4040.1, U2300.2 (GND), U2301.2 (GND), U2302.2 (GND), U2303.2 (GND), U2304.2 (GND), U2305.2 (GND), U2306.1 (GND), U2308.2 (GND), U2310.2 (GND); also elsewhere on the board
NPU_PWM1_M0: R2314.2, R2316.1; also elsewhere on the board
unnamed: C2310.1, R2307.2, R2308.1, R2310.1
unnamed: C2324.1, R2316.2, R2317.1, R2321.1
unnamed: C2353.1, R2354.2, R2355.1, R2356.1
unnamed: ED2300.1, R2351.2, TP4025.1
unnamed: C2301.2, R2301.2, R2304.1, U2300.4 (BP)
unnamed: C2338.1, R2348.2, U2301.1 (EN)
unnamed: C2309.2, R2306.2, R2308.2, R2309.1, U2301.5 (FB/OUT)
unnamed: L2300.1, U2301.3 (LX)
unnamed: C2314.1, U2302.4 (BP)
unnamed: C2340.1, R2350.2, U2302.3 (EN)
unnamed: C2342.1, R2349.2, U2303.1 (EN)
unnamed: C2319.2, R2315.2, R2317.2, R2318.1, U2303.5 (FB/OUT)
unnamed: L2301.1, U2303.3 (LX)
unnamed: C2325.1, R2319.2, U2304.1 (EN)
unnamed: C2322.2, R2320.2, R2322.1, U2304.5 (FB/OUT)
unnamed: L2302.1, U2304.3 (LX)
unnamed: C2333.1, R2325.2, U2305.1 (EN)
unnamed: C2328.2, R2326.2, R2328.1, U2305.5 (FB/OUT)
unnamed: L2303.1, U2305.3 (LX)
unnamed: C2337.1, R2347.2, U2308.1 (EN)
unnamed: C2344.2, R2340.2, R2343.1, U2308.5 (FB/OUT)
unnamed: L2304.1, U2308.3 (LX)
unnamed: C2352.1, R2352.2, U2310.1 (EN)
unnamed: C2354.2, R2356.2, R2357.1, R2358.2, U2310.5 (FB/OUT)
unnamed: L2305.1, U2310.3 (LX)
RESET: R2351.1, U2306.3 (nRST); also elsewhere on the board
VCC_0V8: C2301.1, C2302.1, R2301.1, TP4028.1, U2300.5 (FB/OUT); also elsewhere on the board
VCC_1V8: C2312.1, R2319.1, TP4033.1, U2302.5 (OUT); also elsewhere on the board
VCC_3V3: C2320.1, C2322.1, C2323.1, L2302.2, R2305.1, R2314.1, R2320.1, R2353.1, TP4035.1, U2306.2 (VCC); also elsewhere on the board
VCC_DDR: C2328.1, C2330.1, C2331.1, L2303.2, R2326.1, TP4034.1; also elsewhere on the board
VCC_SYS: C2300.1, C2303.1, C2311.1, C2315.1, C2321.1, C2329.1, C2335.1, C2351.1, R2325.1, R2347.1, R2348.1, R2349.1, R2350.1, R2352.1, U2300.1 (IN), U2300.3 (SHDN), U2301.4 (VIN), U2302.1 (IN), U2303.4 (VIN), U2304.4 (VIN), U2305.4 (VIN), U2308.4 (VIN), U2310.4 (VIN); also elsewhere on the board
VDD_ARM: C2304.1, C2305.1, C2306.1, C2309.1, L2300.2, R2303.1, R2303.2, R2306.1, TP4030.1; also elsewhere on the board
VDD_LOGIC: C2336.1, C2344.1, L2304.2, R2336.1, R2336.2, R2340.1, TP4029.1; also elsewhere on the board
VDD_NPU: C2316.1, C2317.1, C2319.1, C2350.1, L2301.2, R2313.1, R2313.2, R2315.1, TP4031.1; also elsewhere on the board
VDD_VEPU: C2354.1, C2355.1, C2356.1, L2305.2, R2358.1, R2359.1, R2359.2, TP4032.1; also elsewhere on the board
VEPU_PWM2_M0: R2353.2, R2354.1; also elsewhere on the board

Notes on the sheet:
0.718V~~0.975V
FB=0.6V
TYPE: 0.824V
Feedback from far-end
0.72~1.0V
EN High=1.5V
TYPE: 0.81V
FB=0.8V
EN High=1.4V
Power Sequence: 1 VCC_0V8
Power Sequence: 2 VDD_LOGIC
Power Sequence: 2 VDD_ARM
Power Sequence: 2 VDD_NPU
Power Sequence: 3 VCC_1V8
Power Sequence: 5 VCC_3V3
Discrete Power
150K
120K
1.35V
100K
1.5V
1.2V
180K
1.1V
DDR3L
DDR3
DDR4
LPDDR3
LPDDR4
DDR Type
VCC_DDR
Voltage
Default:LPDDR3=1.2V
Power Sequence: 4 VCC_DDR
Total RC delay time =1.97ms
IF R=10K,C=100nF, RC delay :0.5ms
Soft start time:1.2ms
total delay time=1.2ms
RC delay 1.97ms
Total delay time=1.97+1.2=3.17ms

Schematic: p11.kicad_sch, 25.BAT Scheme Wakeup Power

Parts:
C2512, C2523, C2524, C2530, C10004: 100nF; C0402
C2520: 10uF; C0603
C2521, C2522: 1uF; C0402
C2525, C2526: 22uF; C0805
C10000, C10003: 4.7uF; C0402
C10001: 220nF; C0402
C10002: 470pF; C0402
C10005: 47pF; C0402
C10006: 100nF; C0402; not fitted
D2502, D2509, D2511, D2516: 1N4148WS; SOD_323
L2501: 1.0uH; IND_201610
LED2: A-SP1922BS1GHC-C01-3C; SMD_1606-4
Q2500: WPM3401-3/TR; SOT_23
Q2501: MMBT3904; SOT_23
R2510, R2517: 100K; R0402
R2514, R2518, R2531, R2540, R7256, R7257, R7266: 10K; R0402
R2519: 47K; R0402
R2530: 21K; R0402
R2532: 7.15K; R0402
R2533: 30K; R0402
R2537: 24K; R0402
R2538: 1.1K; R0402
R2539: 26.5K; R0402
R2550: 0.02R; R0805
R7267: 5.1K; R0402
R7271: 2K; R0402
R10000: 0R; R0402; not fitted
R10001: 0R; R0805
SW1: EVPAVAA1A; EVQP7C01P
TP4017, TP4018, TP4027: TP; TP_1R00AAAA
TP4036: TP; TP_1R00D
U2500: MP2625BGL-Z; QFN20_3R00X4R00X1R00

Connections:
/P11 25.BAT Scheme Wakeup Power/NTC: C2530.1, R2532.2, R2533.1, TP4027.1, U2500.16 (NTC)
AC_DET: U2500.10 (ACOK#); also elsewhere on the board
ADC_BAT: R7266.2, R7267.1; also elsewhere on the board
CHARGE_M0: U2500.7 (M0); also elsewhere on the board
CHARGE_M1: U2500.8 (M1); also elsewhere on the board
CHG_DET: U2500.9 (CHGOK#); also elsewhere on the board
GND: C2520.2, C2521.2, C2522.2, C2523.2, C2525.2, C2526.2, C2530.2, C10000.2, C10001.2, C10002.2, C10003.2, C10004.2, C10005.2, C10006.2, Q2501.2, R2517.1, R2531.2, R2533.2, R2537.2, R2538.2, R2540.2, R7267.2, SW1.4, TP4018.1, U2500.5 (PGND), U2500.6 (EN#), U2500.11 (AGND); also elsewhere on the board
HALL_OUT: D2516.1; also elsewhere on the board
LED_GR: LED2.3; also elsewhere on the board
LED_OR: LED2.2; also elsewhere on the board
unnamed: C2512.2, Q2500.1, R2510.2, R2518.2, R7256.2
unnamed: C10006.1, R10000.2
unnamed: D2502.2, D2509.2, D2516.2, R2514.1
unnamed: D2509.1, R2519.1
unnamed: D2511.2, R7256.1, SW1.2
unnamed: LED2.1, LED2.4, R7271.1
unnamed: Q2501.1, R2514.2, R2517.2
unnamed: Q2501.3, R2518.1
unnamed: C2526.1, R2550.1, U2500.14 (BATT)
unnamed: C2524.1, U2500.1 (BST)
unnamed: R2537.1, U2500.17 (ILIM)
unnamed: C2520.1, C2521.1, C10000.1, C10001.1, C10002.1, R2530.1, R10000.1, R10001.2, U2500.3 (IN)
unnamed: R2538.1, U2500.15 (ISET)
unnamed: C2524.2, L2501.1, U2500.2 (SW1), U2500.4 (SW2)
unnamed: R2539.2, R2540.1, U2500.12 (SYSFB)
unnamed: C2523.1, U2500.18 (TMR)
unnamed: C2522.1, R2532.1, U2500.20 (VCC)
unnamed: R2530.2, R2531.1, U2500.19 (VLIM)
POWER_KEY: D2511.1, R7257.2; also elsewhere on the board
POW_HOLD: D2502.1; also elsewhere on the board
VCC5V0_USB: R2519.2, R10001.1; also elsewhere on the board
VCCSYS_IN: C2512.1, C2525.1, C10003.1, C10004.1, C10005.1, L2501.2, Q2500.2, R2510.1, R2539.1, TP4036.1, U2500.13 (SYS); also elsewhere on the board
VCC_3V3: R7257.1, R7271.2; also elsewhere on the board
VCC_BAT: R2550.2, R7266.1, TP4017.1
VCC_SYS: Q2500.3; also elsewhere on the board

Notes on the sheet:
ISET=1.15*1800/R2538(mA)
ISET=1.88A
ILIM=1.9A
ILIM=1.14*40000/R2537(mA)
Recommend 10K NTC resistor for Battery.
Or the values of R2532 and R2533
are needed to change.
CHARGE
POWER_SW
此处电源需匹配对应
电源域
POWER_LED

Schematic: p12.kicad_sch, 26.USB OTG

Parts:
C2600: 22uF; C0805
C2601, C2602: 100nF; C0402
D2514: ESD5471X; ESD0402
ESD2600: ESD5302F; SOT_23
R2600, R2602: 2.2R; R0603
R2603: 18K; R0402
R2604: 10K; R0402
R7280, R7281: 5.1K; R0402
TP4041, TP4042, TP4043, TP4044: TP; TP_1R00D
TYPE_C1: TYPE_C

Connections:
/P12 26.USB OTG/OTGDM: ESD2600.2, R2602.1, TP4043.1, TYPE_C1.7 (DN1), TYPE_C1.19 (DN2)
/P12 26.USB OTG/OTGDP: ESD2600.1, R2600.1, TP4042.1, TYPE_C1.6 (DP1), TYPE_C1.18 (DP2)
GND: C2600.2, C2601.2, C2602.2, D2514.2, ESD2600.3, R2604.1, R7280.2, R7281.2, TP4044.1, TYPE_C1.1 (GND), TYPE_C1.12 (GND), TYPE_C1.13 (GND), TYPE_C1.24 (GND), TYPE_C1.25 (GND), TYPE_C1.26 (GND), TYPE_C1.27 (GND), TYPE_C1.28 (GND), TYPE_C1.29 (GND), TYPE_C1.30 (GND); also elsewhere on the board
unnamed: R7281.1, TYPE_C1.5 (CC1)
unnamed: R7280.1, TYPE_C1.17 (CC2)
OTG_DET_1V8: C2602.1, R2603.2, R2604.2; also elsewhere on the board
OTG_DM: R2602.2; also elsewhere on the board
OTG_DP: R2600.2; also elsewhere on the board
VCC5V0_USB: C2600.1, C2601.1, D2514.1, R2603.1, TP4041.1, TYPE_C1.4 (VBUS), TYPE_C1.9 (VBUS), TYPE_C1.16 (VBUS), TYPE_C1.21 (VBUS); also elsewhere on the board

Notes on the sheet:
2.2R
220R
3906
USB2.0 OTG
This circuit is used to improve usb compatibility.
Note:
These components are close to R2602 to avoid long branches.

Schematic: p13.kicad_sch, 31. DRAM_LPDDR3_32 bit

Parts:
C3200, C3202: 10nF; C0402
C3201, C3203, C3230, C3233: 1nF; C0402
C3204, C3209: 4.7uF; C0402
C3205, C3206, C3207, C3208, C3210, C3211, C3212, C3216, C3217, C3218, C3219, C3220, C3221, C3222, C3223, C3224, C3225, C3226, C3227, C3228, C3229, C3231, C3232, C3234, C3235, C3236, C3237, C3238, C3239, C3240, C3241, C3242, C3243, C3244, C3247, C3249: 100nF; C0402
C3213, C3214, C3215: 22uF; C0603
C3245: 1nF; C0402; not fitted
C3246, C3248: 2.2uF; C0402
C9852: 100pF; C0402
R3200, R3201: 240R; R0402
R3202, R3203, R3217: 10K; R0402
R3204, R3205: 49.9R; R0402
R3206: 0R; R0402
R3207: R0402
R3208, R3209, R3210: 1K; R0402
TP4037: TP; TP_1R00D
U3200, U3201: DDR4X16; FBGA96_14R00X11R00X1R20
U3233: PT5108E23E-25; SOT_23_5

Connections:
DDR3_A1: U3200.R2 (A8), U3201.R2 (A8); also elsewhere on the board
DDR3_A3: U3200.P3 (A0), U3201.P3 (A0); also elsewhere on the board
DDR3_A4: U3200.R8 (A7), U3201.R8 (A7); also elsewhere on the board
DDR3_A5: U3200.R7 (A9), U3201.R7 (A9); also elsewhere on the board
DDR3_A6: U3200.N3 (A4), U3201.N3 (A4); also elsewhere on the board
DDR3_A7: U3200.T2 (A11), U3201.T2 (A11); also elsewhere on the board
DDR3_A8: U3200.M3 (A10/AP), U3201.M3 (A10/AP); also elsewhere on the board
DDR3_A9: U3200.R3 (A2), U3201.R3 (A2); also elsewhere on the board
DDR3_A10: U3200.M8 (CAS_n/A15), U3201.M8 (CAS_n/A15); also elsewhere on the board
DDR3_A11: U3200.L8 (RAS_n/A16), U3201.L8 (RAS_n/A16); also elsewhere on the board
DDR3_A12: U3200.P8 (A5), U3201.P8 (A5); also elsewhere on the board
DDR3_A13: U3200.T8 (A13), U3201.T8 (A13); also elsewhere on the board
DDR3_A14: U3200.L2 (WE_n/A14), U3201.L2 (WE_n/A14); also elsewhere on the board
DDR3_A15: U3200.N7 (A3), U3201.N7 (A3); also elsewhere on the board
DDR3_BA1: U3200.P7 (A1), U3201.P7 (A1); also elsewhere on the board
DDR3_BA2: U3200.P2 (A6), U3201.P2 (A6); also elsewhere on the board
DDR3_CASN: U3200.K2 (CKE), U3201.K2 (CKE); also elsewhere on the board
DDR3_CKE: U3200.L3 (ACT_n), U3201.L3 (ACT_n); also elsewhere on the board
DDR3_CLKN: R3205.1, U3200.K8 (CK_N), U3201.K8 (CK_N); also elsewhere on the board
DDR3_CLKP: R3204.1, U3200.K7 (CK_P), U3201.K7 (CK_P); also elsewhere on the board
DDR3_CS0N: U3200.K3 (ODT), U3201.K3 (ODT); also elsewhere on the board
DDR3_CS1N: U3200.N2 (BA0), U3201.N2 (BA0); also elsewhere on the board
DDR3_ODT0: U3200.L7 (CS_n), U3201.L7 (CS_n); also elsewhere on the board
DDR3_ODT1: U3200.M2 (BG0), U3201.M2 (BG0); also elsewhere on the board
DDR3_RASN: U3200.M7 (A12/BC_n), U3201.M7 (A12/BC_n); also elsewhere on the board
DDR3_RST: C3245.1, U3200.P1 (RESET_n), U3201.P1 (RESET_n); also elsewhere on the board
DDR3_WEN: U3200.N8 (BA1), U3201.N8 (BA1); also elsewhere on the board
DDR_D0: U3200.J3 (DQL6); also elsewhere on the board
DDR_D1: U3200.G2 (DQL0); also elsewhere on the board
DDR_D2: U3200.H7 (DQL3); also elsewhere on the board
DDR_D3: U3200.H8 (DQL5); also elsewhere on the board
DDR_D4: U3200.H2 (DQL4); also elsewhere on the board
DDR_D5: U3200.H3 (DQL2); also elsewhere on the board
DDR_D6: U3200.J7 (DQL7); also elsewhere on the board
DDR_D7: U3200.F7 (DQL1); also elsewhere on the board
DDR_D8: U3201.C3 (DQU2); also elsewhere on the board
DDR_D9: U3201.D3 (DQU6); also elsewhere on the board
DDR_D10: U3201.C8 (DQU5); also elsewhere on the board
DDR_D11: U3201.D7 (DQU7); also elsewhere on the board
DDR_D12: U3201.B8 (DQU1); also elsewhere on the board
DDR_D13: U3201.C7 (DQU3); also elsewhere on the board
DDR_D14: U3201.C2 (DQU4); also elsewhere on the board
DDR_D15: U3201.A3 (DQU0); also elsewhere on the board
DDR_D16: U3200.C3 (DQU2); also elsewhere on the board
DDR_D17: U3200.A3 (DQU0); also elsewhere on the board
DDR_D18: U3200.D3 (DQU6); also elsewhere on the board
DDR_D19: U3200.C2 (DQU4); also elsewhere on the board
DDR_D20: U3200.C8 (DQU5); also elsewhere on the board
DDR_D21: U3200.D7 (DQU7); also elsewhere on the board
DDR_D22: U3200.C7 (DQU3); also elsewhere on the board
DDR_D23: U3200.B8 (DQU1); also elsewhere on the board
DDR_D24: U3201.H2 (DQL4); also elsewhere on the board
DDR_D25: U3201.G2 (DQL0); also elsewhere on the board
DDR_D26: U3201.F7 (DQL1); also elsewhere on the board
DDR_D27: U3201.J7 (DQL7); also elsewhere on the board
DDR_D28: U3201.H8 (DQL5); also elsewhere on the board
DDR_D29: U3201.H7 (DQL3); also elsewhere on the board
DDR_D30: U3201.H3 (DQL2); also elsewhere on the board
DDR_D31: U3201.J3 (DQL6); also elsewhere on the board
DDR_DM0: U3200.E7 (DML_n/DBIL_n); also elsewhere on the board
DDR_DM1: U3201.E2 (DMU_n/DBIU_n); also elsewhere on the board
DDR_DM2: U3200.E2 (DMU_n/DBIU_n); also elsewhere on the board
DDR_DM3: U3201.E7 (DML_n/DBIL_n); also elsewhere on the board
DDR_DQS0N: U3200.F3 (DQSL_N); also elsewhere on the board
DDR_DQS0P: U3200.G3 (DQSL_P); also elsewhere on the board
DDR_DQS1N: U3201.A7 (DQSU_N); also elsewhere on the board
DDR_DQS1P: U3201.B7 (DQSU_P); also elsewhere on the board
DDR_DQS2N: U3200.A7 (DQSU_N); also elsewhere on the board
DDR_DQS2P: U3200.B7 (DQSU_P); also elsewhere on the board
DDR_DQS3N: U3201.F3 (DQSL_N); also elsewhere on the board
DDR_DQS3P: U3201.G3 (DQSL_P); also elsewhere on the board
GND: C3200.2, C3201.2, C3202.2, C3203.2, C3204.2, C3205.2, C3206.2, C3207.2, C3208.2, C3209.2, C3210.2, C3211.2, C3212.2, C3213.2, C3214.2, C3215.2, C3216.2, C3217.2, C3218.2, C3219.2, C3220.2, C3221.2, C3222.2, C3223.2, C3224.2, C3225.2, C3226.2, C3227.2, C3228.2, C3229.2, C3230.2, C3231.2, C3232.2, C3233.2, C3234.2, C3235.2, C3236.2, C3237.2, C3238.2, C3239.2, C3240.2, C3241.2, C3242.2, C3243.2, C3244.2, C3245.2, C3246.2, C3247.2, C3248.2, C3249.2, C9852.2, R3200.2, R3201.2, R3203.2, R3207.2, R3208.2, R3209.2, R3210.2, U3200.A2 (VSSQ1), U3200.A8 (VSSQ2), U3200.B2 (VSS1), U3200.C9 (VSSQ3), U3200.D2 (VSSQ4), U3200.D8 (VSSQ5), U3200.E1 (VSS2), U3200.E3 (VSSQ6), U3200.E8 (VSSQ7), U3200.E9 (VSS3), U3200.F1 (VSSQ8), U3200.G8 (VSS4), U3200.H1 (VSSQ9), U3200.H9 (VSSQ10), U3200.K1 (VSS5), U3200.K9 (VSS6), U3200.M9 (VSS7), U3200.N1 (VSS8), U3200.T1 (VSS9), U3201.A2 (VSSQ1), U3201.A8 (VSSQ2), U3201.B2 (VSS1), U3201.C9 (VSSQ3), U3201.D2 (VSSQ4), U3201.D8 (VSSQ5), U3201.E1 (VSS2), U3201.E3 (VSSQ6), U3201.E8 (VSSQ7), U3201.E9 (VSS3), U3201.F1 (VSSQ8), U3201.G8 (VSS4), U3201.H1 (VSSQ9), U3201.H9 (VSSQ10), U3201.K1 (VSS5), U3201.K9 (VSS6), U3201.M9 (VSS7), U3201.N1 (VSS8), U3201.T1 (VSS9), U3233.2 (GND); also elsewhere on the board
unnamed: C9852.1, R3204.2, R3205.2
unnamed: R3208.1, U3200.T3 (PAR)
unnamed: R3207.1, U3200.N9 (TEN)
unnamed: R3200.1, U3200.F9 (ZQ)
unnamed: R3209.1, U3201.T3 (PAR)
unnamed: R3210.1, U3201.N9 (TEN)
unnamed: R3201.1, U3201.F9 (ZQ)
unnamed: C3247.1, U3233.4 (BP)
unnamed: R3217.2, U3233.3 (EN)
VCC25_DDR: C3204.1, C3205.1, C3206.1, C3207.1, C3208.1, C3209.1, C3210.1, C3211.1, C3212.1, C3248.1, C3249.1, TP4037.1, U3200.B1 (VPP1), U3200.R9 (VPP2), U3201.B1 (VPP1), U3201.R9 (VPP2), U3233.5 (OUT)
VCC_DDR: C3213.1, C3214.1, C3215.1, C3216.1, C3217.1, C3218.1, C3219.1, C3220.1, C3221.1, C3222.1, C3223.1, C3224.1, C3225.1, C3226.1, C3227.1, C3228.1, C3229.1, C3230.1, C3231.1, C3232.1, C3233.1, C3234.1, C3235.1, C3236.1, C3237.1, C3238.1, C3239.1, C3240.1, C3241.1, C3242.1, C3243.1, C3244.1, R3202.1, U3200.A1 (VDDQ1), U3200.A9 (VDDQ2), U3200.B3 (VDD1), U3200.B9 (VDD2), U3200.C1 (VDDQ3), U3200.D1 (VDD3), U3200.D9 (VDDQ4), U3200.F2 (VDDQ5), U3200.F8 (VDDQ6), U3200.G1 (VDDQ7), U3200.G7 (VDD4), U3200.G9 (VDDQ8), U3200.J1 (VDD5), U3200.J2 (VDDQ9), U3200.J8 (VDDQ10), U3200.J9 (VDD6), U3200.L1 (VDD7), U3200.L9 (VDD8), U3200.R1 (VDD9), U3200.T9 (VDD10), U3201.A1 (VDDQ1), U3201.A9 (VDDQ2), U3201.B3 (VDD1), U3201.B9 (VDD2), U3201.C1 (VDDQ3), U3201.D1 (VDD3), U3201.D9 (VDDQ4), U3201.F2 (VDDQ5), U3201.F8 (VDDQ6), U3201.G1 (VDDQ7), U3201.G7 (VDD4), U3201.G9 (VDDQ8), U3201.J1 (VDD5), U3201.J2 (VDDQ9), U3201.J8 (VDDQ10), U3201.J9 (VDD6), U3201.L1 (VDD7), U3201.L9 (VDD8), U3201.R1 (VDD9), U3201.T9 (VDD10); also elsewhere on the board
VCC_SYS: C3246.1, R3217.1, U3233.1 (IN); also elsewhere on the board
VREF_DDR: R3206.2; also elsewhere on the board
VREF_DDR4_CA: C3200.1, C3201.1, C3202.1, C3203.1, R3202.2, R3203.1, R3206.1, U3200.M1 (VREFCA), U3201.M1 (VREFCA)

Notes on the sheet:
Refer to the latest AVL for parts selection.
DDR4 2x16bit
NOTE:
The sequence of DQ shall be done according to the template
and shall not be adjusted or changed
Note:
This is DDR template<RV1126_RV1109_Template_DDR4P216DD6_V10_20200325>.Six layers PCB.
If only need one pcs DDR, please must use U3200(lane0,lane2).
DNP

Schematic: p14.kicad_sch, 40.Flash-eMMC Flash

Parts:
C4000, C4004, C4006, C4007: 4.7uF; C0402
C4001, C4002, C4005: 100nF; C0402
C4003: 1uF; C0402
C4008: 100nF; C0402; not fitted
R4000: 0R; R0402
R4003, R4004: 4.7K; R0402
TP4000, TP4001: TP; TP_1R00
TP4038: TP; TP_1R00D
U4000: KLM8G1GETF-B041; BGA153_13RX11R5X0R9_2L
U4001: WL2808E18-5/TR; SOT_23_5; not fitted

Connections:
EMMC_CLKO/FLASH_CLE: R4000.1; also elsewhere on the board
EMMC_CMD/FLASH_WRN: R4003.2, U4000.M5 (CMD); also elsewhere on the board
EMMC_D0/FLASH_D0: R4004.2, TP4000.1, U4000.A3 (DATA0); also elsewhere on the board
EMMC_D1/FLASH_D1: U4000.A4 (DATA1); also elsewhere on the board
EMMC_D2/FLASH_D2: U4000.A5 (DATA2); also elsewhere on the board
EMMC_D3/FLASH_D3: U4000.B2 (DATA3); also elsewhere on the board
EMMC_D4/FLASH_D4: U4000.B3 (DATA4); also elsewhere on the board
EMMC_D5/FLASH_D5: U4000.B4 (DATA5); also elsewhere on the board
EMMC_D6/FLASH_D6: U4000.B5 (DATA6); also elsewhere on the board
EMMC_D7/FLASH_D7: U4000.B6 (DATA7); also elsewhere on the board
FSPI_CLK/EMMC_RSTN/FLASH_WPN: U4000.K5 (RST_n); also elsewhere on the board
GND: C4000.2, C4001.2, C4002.2, C4003.2, C4004.2, C4005.2, C4006.2, C4007.2, C4008.2, TP4001.1, U4000.A6 (VSS2), U4000.C4 (VSS3), U4000.E7 (VSS4), U4000.G5 (VSS5), U4000.H10 (VSS6), U4000.J5 (VSS1), U4000.K8 (VSSQ1), U4000.N2 (VSSQ2), U4000.N5 (VSSQ3), U4000.P4 (VSSQ4), U4000.P6 (VSSQ5), U4001.2 (GND); also elsewhere on the board
unnamed: R4000.2, U4000.M6 (CLK)
unnamed: C4003.1, U4000.C2 (VDDi)
unnamed: C4008.1, U4001.4 (BP)
VCCIO_FLASH: C4000.1, C4001.1, C4002.1, C4007.1, R4003.1, R4004.1, TP4038.1, U4000.C6 (VDD1), U4000.M4 (VDD2), U4000.N4 (VDD3), U4000.P3 (VDD4), U4000.P5 (VDD5), U4001.5 (OUT); also elsewhere on the board
VCC_3V3: C4004.1, C4005.1, C4006.1, U4000.E6 (VDDF1), U4000.F5 (VDDF2), U4000.J10 (VDDF3), U4000.K9 (VDDF4), U4001.1 (IN), U4001.3 (EN); also elsewhere on the board

Notes on the sheet:
eMMC
NOTE:
Refer to the latest AVL for parts selection.
All the power filter capacitors should be placed close to the power pins of SOC.
OPTION:
If EMMC peak current > 300mA,
please use LDO supply
R4000 place close to SOC
500mA

Schematic: p15.kicad_sch, Page 15

Parts:
C10007, C10008, C10009, C10010: 待確認; C0201
FPC1: 0.3MM_FPC_39P
R10002, R10003: 待確認; R0201

Connections:
GND: C10007.1, C10008.1, C10009.1, C10010.1, FPC1.1, FPC1.4, FPC1.7, FPC1.10, FPC1.12, FPC1.17, FPC1.19, FPC1.22, FPC1.25, FPC1.28, FPC1.31, FPC1.33, FPC1.38, FPC1.39; also elsewhere on the board
I2C1_SCL: FPC1.13; also elsewhere on the board
I2C1_SDA: FPC1.14; also elsewhere on the board
I2C3_SCL_M2: FPC1.34; also elsewhere on the board
I2C3_SDA_M2: FPC1.35; also elsewhere on the board
MIPI_CSI_CLK0: C10009.2, R10003.2; also elsewhere on the board
MIPI_CSI_CLK0_FPC: FPC1.32, R10003.1
MIPI_CSI_CLK1: C10010.2, R10002.1; also elsewhere on the board
MIPI_CSI_CLK1_FPC: FPC1.11, R10002.2
MIPI_CSI_RX0_CLKN: FPC1.30; also elsewhere on the board
MIPI_CSI_RX0_CLKP: FPC1.29; also elsewhere on the board
MIPI_CSI_RX0_D0N: FPC1.24; also elsewhere on the board
MIPI_CSI_RX0_D0P: FPC1.23; also elsewhere on the board
MIPI_CSI_RX0_D1N: FPC1.27; also elsewhere on the board
MIPI_CSI_RX0_D1P: FPC1.26; also elsewhere on the board
MIPI_CSI_RX1_CLKN: FPC1.9; also elsewhere on the board
MIPI_CSI_RX1_CLKP: FPC1.8; also elsewhere on the board
MIPI_CSI_RX1_D0N: FPC1.3; also elsewhere on the board
MIPI_CSI_RX1_D0P: FPC1.2; also elsewhere on the board
MIPI_CSI_RX1_D1N: FPC1.6; also elsewhere on the board
MIPI_CSI_RX1_D1P: FPC1.5; also elsewhere on the board
RGB_PWDN: FPC1.15; also elsewhere on the board
RGB_RESET: C10008.2, FPC1.16; also elsewhere on the board
UV_PWDN: FPC1.36; also elsewhere on the board
UV_RESET: C10007.2, FPC1.37; also elsewhere on the board
VCC_SYS: FPC1.20, FPC1.21; also elsewhere on the board

Notes on the sheet:
等待最终
CAM
规格书
以下 6 顆依 Layout 1.5.2-H 補入(原 PDF 沒有)，值待確認

Schematic: p16.kicad_sch, Page 16

Parts:
C9893: 10uf; C0603
C9894: 22uf; C0603
C9897, C9898: 4.7uF; C0402
C9899: 100nF; C0402; not fitted
C9999: 100nF; C0402
D2515: PMEG4030ER; SOD_123
FPC2: 0.3MM_FPC_21P
L2506: 10uH; IND_252010
R7268: 10R; R0603
TP4039: TP; TP_1R00D
U4012: SGM3766YTN5G/TR; SOT_23_5
U4015: WL2808E28-5/TR; SOT_23_5

Connections:
/P16 Page 16/LEDA: C9893.1, D2515.2, FPC2.3
/P16 Page 16/LEDK: FPC2.2, R7268.1, U4012.3 (FB)
CTP_INT: FPC2.18; also elsewhere on the board
CTP_RST: FPC2.19; also elsewhere on the board
GND: C9893.2, C9894.2, C9897.2, C9898.2, C9899.2, C9999.2, FPC2.1, FPC2.4, FPC2.9, FPC2.12, FPC2.15, FPC2.21, R7268.2, U4012.2 (GND), U4015.2 (GND); also elsewhere on the board
I2C2_SCL: FPC2.17; also elsewhere on the board
I2C2_SDA: FPC2.16; also elsewhere on the board
LCD_RST: C9999.1, FPC2.8; also elsewhere on the board
MIPI_DSI_TX0_CLKN: FPC2.13; also elsewhere on the board
MIPI_DSI_TX0_CLKP: FPC2.14; also elsewhere on the board
MIPI_DSI_TX0_D0N: FPC2.10; also elsewhere on the board
MIPI_DSI_TX0_D0P: FPC2.11; also elsewhere on the board
unnamed: D2515.1, L2506.2, U4012.1 (SW)
unnamed: C9899.1, U4015.4 (BP)
PWM_LCD: U4012.4 (CTRL); also elsewhere on the board
VCC_1V8: FPC2.7; also elsewhere on the board
VCC_2.8V: C9897.1, FPC2.6, TP4039.1, U4015.5 (OUT)
VCC_3V3: C9898.1, FPC2.20, U4015.1 (IN), U4015.3 (EN); also elsewhere on the board
VCC_SYS: C9894.1, L2506.1, U4012.5 (VIN); also elsewhere on the board

Notes on the sheet:
等待最终屏幕规格书
添加背光驱动
500mA
VCC_3V3

Schematic: p17.kicad_sch, Page 17

Parts:
C9877, C9878, C9888, C9891: 22uf; C0603
C9889, C9890: 10uf; C0603
D2512, D2513: PMEG4030ER; SOD_123
L2502: 4.7uH; IND_252010
L2504, L2505: 10uH; IND_252010
LED4: UV_LED; LED_3535
R7258: 200mR; R0805
R7261, R7262: 6.2R; R0603
TP4011, TP4012, TP4013, TP4014: TP; TP_1R00CAAAAA
U4003: PAM2804AAB010; SOT_23_5
U4008, U4009: SGM3766YTN5G/TR; SOT_23_5

Connections:
/P17 Page 17/CW_LED+: C9889.1, D2512.2, TP4013.1
/P17 Page 17/CW_LED-: R7261.1, TP4014.1, U4008.3 (FB)
/P17 Page 17/UV_LED+: C9877.1, L2502.1, LED4.1
/P17 Page 17/UV_LED-: LED4.3, R7258.1, U4003.5 (FB)
/P17 Page 17/WW_LED+: C9890.1, D2513.2, TP4011.1
/P17 Page 17/WW_LED-: R7262.1, TP4012.1, U4009.3 (FB)
CW_LED_PWM: U4008.4 (CTRL); also elsewhere on the board
GND: C9877.2, C9878.2, C9888.2, C9889.2, C9890.2, C9891.2, LED4.2, R7258.2, R7261.2, R7262.2, U4003.2 (GND), U4008.2 (GND), U4009.2 (GND); also elsewhere on the board
unnamed: L2502.2, U4003.3 (SW)
unnamed: D2512.1, L2504.2, U4008.1 (SW)
unnamed: D2513.1, L2505.2, U4009.1 (SW)
UV_LED_PWM: U4003.1 (EN); also elsewhere on the board
VCC_SYS: C9878.1, C9888.1, C9891.1, L2504.1, L2505.1, U4003.4 (VIN), U4008.5 (VIN), U4009.5 (VIN); also elsewhere on the board
WW_LED_PWM: U4009.4 (CTRL); also elsewhere on the board

Notes on the sheet:
ILED = Duty *( 0.1/RS)
CCTLED DRV
UVLED DRV
ILED max =100mA

Schematic: p18.kicad_sch, Page 18

Parts:
C9879, C9884: 100nF; C0402
C9885: 10uF; C0603
C9886: 10pF; C0402
FPC3: 0.5MM_FPC_8P
Q2602: WPM3400-3/TR; SOT_23
Q2603: MMBT3904; SOT_23
R7259, R7263, R7264, R7272: 10K; R0402
R7260: 1K; R0402
R7269, R7270: 0R; R0402
R7273: 100K; R0402
TP4008: TOUCH_PAD; TOUCH_PADAA
TP4009, TP4010: TP; TP_1R00AAAA
U4010: JL523B; SOT_23_6
U4014: GXHTC3; QFN2_2_0.75

Connections:
GND: C9879.2, C9884.2, C9885.2, C9886.2, FPC3.7, FPC3.8, FPC3.9, FPC3.10, Q2602.2, Q2603.2, R7263.1, R7273.1, U4010.2 (GND), U4010.6 (STG), U4014.6 (GND), U4014.7 (EPAD); also elsewhere on the board
HALL_OUT: R7269.1, R7270.1, R7272.1; also elsewhere on the board
HALL_OUT_CPU: Q2603.3; also elsewhere on the board
I2C4_SCL_M0: FPC3.3, U4014.3 (SCL); also elsewhere on the board
I2C4_SDA_M0: FPC3.2, U4014.4 (SDA); also elsewhere on the board
L_MOTOR_CTR: R7264.1; also elsewhere on the board
unnamed: FPC3.5, R7269.2
unnamed: FPC3.6, R7270.2
unnamed: Q2602.1, R7263.2, R7264.2
unnamed: Q2602.3, TP4010.1
unnamed: Q2603.1, R7272.2, R7273.2
unnamed: R7260.1, TP4008.1
unnamed: R7259.2, U4010.1 (OUT)
unnamed: C9886.1, R7260.2, U4010.3 (SO)
TOUCH_OUT: R7259.1; also elsewhere on the board
VCCSYS_IN: FPC3.4; also elsewhere on the board
VCC_3V3: C9879.1, C9884.1, C9885.1, FPC3.1, TP4009.1, U4010.4 (SLH), U4010.5 (VDD), U4014.1 (VDD); also elsewhere on the board

Notes on the sheet:
线性马达
TEMPERATURE && HUMIDITY
UV-DETECTION
TOUCH BUTTON
HALL
DNP
