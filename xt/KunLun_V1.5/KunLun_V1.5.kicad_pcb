# Repository hsiao920/pcba (continued)

## KiCad design xt/KunLun_V1.5/KunLun_V1.5.kicad_pcb (continued)

Board: 6 copper layers, 70.9 x 68.5 mm, 389 parts (159 on the bottom side), 251 nets.

File xt/KunLun_V1.5/KunLun_V1.5_bom.csv (part):

"Refs","Value","Footprint","Qty","DNP"
"C1000","1nF","Capacitor_SMD:C_0201_0603Metric","1",""
"C1001","100nF","Capacitor_SMD:C_0201_0603Metric","1",""
"C1002","100nF","Capacitor_SMD:C_0201_0603Metric","1",""
"C1003","100nF","Capacitor_SMD:C_0201_0603Metric","1",""
"C1004","1uF","Capacitor_SMD:C_0402_1005Metric","1",""
"C1005","1uF","Capacitor_SMD:C_0402_1005Metric","1",""
"C1006","10uF","Capacitor_SMD:C_0402_1005Metric","1",""
"C1007","100nF","Capacitor_SMD:C_0201_0603Metric","1",""
"C1008","100nF","Capacitor_SMD:C_0201_0603Metric","1",""
"C1009","1uF","Capacitor_SMD:C_0402_1005Metric","1",""
"C1010","1uF","Capacitor_SMD:C_0402_1005Metric","1",""
"C1011","10uF","Capacitor_SMD:C_0402_1005Metric","1",""
"C1012","100nF","Capacitor_SMD:C_0201_0603Metric","1",""
"C1013","100nF","Capacitor_SMD:C_0201_0603Metric","1",""
"C1014","1uF","Capacitor_SMD:C_0402_1005Metric","1",""
"C1015","10uF","Capacitor_SMD:C_0402_1005Metric","1",""
"C1016","100nF","Capacitor_SMD:C_0201_0603Metric","1",""
"C1017","100nF","Capacitor_SMD:C_0201_0603Metric","1",""
"C1018","1uF","Capacitor_SMD:C_0402_1005Metric","1",""
"C1019","10uF","Capacitor_SMD:C_0402_1005Metric","1",""
"C1100","12pF","Capacitor_SMD:C_0402_1005Metric","1",""
"C1101","12pF","Capacitor_SMD:C_0402_1005Metric","1",""
"C1103","100nF","Capacitor_SMD:C_0201_0603Metric","1",""
"C1104","100nF","Capacitor_SMD:C_0201_0603Metric","1",""
"C1106","100nF","Capacitor_SMD:C_0402_1005Metric","1",""
"C1107","100nF","Capacitor_SMD:C_0201_0603Metric","1",""
"C1108","100nF","Capacitor_SMD:C_0201_0603Metric","1",""
"C1203","1uF","Capacitor_SMD:C_0402_1005Metric","1",""
"C1204","1uF","Capacitor_SMD:C_0402_1005Metric","1",""
"C1205","1uF","Capacitor_SMD:C_0402_1005Metric","1",""
"C1206","10uF","Capacitor_SMD:C_0603_1608Metric","1",""
"C1300","100nF","Capacitor_SMD:C_0201_0603Metric","1",""
"C1301","100nF","Capacitor_SMD:C_0201_0603Metric","1",""
"C1302","100nF","Capacitor_SMD:C_0201_0603Metric","1",""
"C1400","100nF","Capacitor_SMD:C_0201_0603Metric","1",""
"C1401","100nF","Capacitor_SMD:C_0201_0603Metric","1",""
"C1402","100nF","Capacitor_SMD:C_0201_0603Metric","1",""
"C1501","100nF","Capacitor_SMD:C_0201_0603Metric","1",""
"C1600","100nF","Capacitor_SMD:C_0201_0603Metric","1",""
"C1601","100nF","Capacitor_SMD:C_0201_0603Metric","1",""
"C1602","100nF","Capacitor_SMD:C_0201_0603Metric","1",""
"C1603","100nF","Capacitor_SMD:C_0201_0603Metric","1",""
"C1700","100nF","Capacitor_SMD:C_0201_0603Metric","1",""
"C1800","100nF","Capacitor_SMD:C_0201_0603Metric","1",""
"C2300","1uF","Capacitor_SMD:C_0402_1005Metric","1",""
"C2301","22pF","Capacitor_SMD:C_0402_1005Metric","1",""
"C2302","4.7uF","Capacitor_SMD:C_0402_1005Metric","1",""
"C2303","10uF","Capacitor_SMD:C_0603_1608Metric","1",""
"C2304","22uF","Capacitor_SMD:C_0603_1608Metric","1",""
"C2305","22uF","Capacitor_SMD:C_0603_1608Metric","1",""
"C2306","100nF","Capacitor_SMD:C_0402_1005Metric","1",""
"C2309","100pF","Capacitor_SMD:C_0402_1005Metric","1",""
"C2310","10nF","Capacitor_SMD:C_0402_1005Metric","1",""
"C2311","1uF","Capacitor_SMD:C_0402_1005Metric","1",""
"C2312","4.7uF","Capacitor_SMD:C_0402_1005Metric","1",""
"C2314","100nF","Capacitor_SMD:C_0402_1005Metric","1","DNP (不作裝配)"
"C2315","10uF","Capacitor_SMD:C_0603_1608Metric","1",""
"C2316","22uF","Capacitor_SMD:C_0603_1608Metric","1",""
"C2317","100nF","Capacitor_SMD:C_0402_1005Metric","1",""
"C2319","220pF","Capacitor_SMD:C_0402_1005Metric","1",""
"C2320","10uF","Capacitor_SMD:C_0402_1005Metric","1",""
"C2321","4.7uF","Capacitor_SMD:C_0402_1005Metric","1",""
"C2322","100pF","Capacitor_SMD:C_0402_1005Metric","1",""
"C2323","100nF","Capacitor_SMD:C_0402_1005Metric","1",""
"C2324","10nF","Capacitor_SMD:C_0402_1005Metric","1",""
"C2325","100nF","Capacitor_SMD:C_0402_1005Metric","1",""
"C2328","100pF","Capacitor_SMD:C_0402_1005Metric","1",""
"C2329","4.7uF","Capacitor_SMD:C_0402_1005Metric","1",""
"C2330","10uF","Capacitor_SMD:C_0402_1005Metric","1",""
"C2331","100nF","Capacitor_SMD:C_0402_1005Metric","1",""
"C2333","100nF","Capacitor_SMD:C_0402_1005Metric","1",""
"C2335","10uF","Capacitor_SMD:C_0603_1608Metric","1",""
"C2336","22uF","Capacitor_SMD:C_0603_1608Metric","1",""
"C2337","100nF","Capacitor_SMD:C_0402_1005Metric","1","DNP (不作裝配)"
"C2338","100nF","Capacitor_SMD:C_0402_1005Metric","1","DNP (不作裝配)"
"C2340","100nF","Capacitor_SMD:C_0402_1005Metric","1",""
"C2342","100nF","Capacitor_SMD:C_0402_1005Metric","1","DNP (不作裝配)"
"C2344","100pF","Capacitor_SMD:C_0402_1005Metric","1",""
"C2350","22uF","Capacitor_SMD:C_0603_1608Metric","1",""
"C2351","10uF","Capacitor_SMD:C_0603_1608Metric","1",""
"C2352","100nF","Capacitor_SMD:C_0402_1005Metric","1","DNP (不作裝配)"
"C2353","10nF","Capacitor_SMD:C_0402_1005Metric","1",""
"C2354","100pF","Capacitor_SMD:C_0402_1005Metric","1",""
"C2355","22uF","Capacitor_SMD:C_0603_1608Metric","1",""
"C2356","100nF","Capacitor_SMD:C_0402_1005Metric","1",""
"C2512","100nF","Capacitor_SMD:C_0402_1005Metric","1",""
"C2520","10uF","Capacitor_SMD:C_0603_1608Metric","1",""
"C2521","1uF","Capacitor_SMD:C_0402_1005Metric","1",""
"C2522","1uF","Capacitor_SMD:C_0402_1005Metric","1",""
"C2523","100nF","Capacitor_SMD:C_0402_1005Metric","1",""
"C2524","100nF","Capacitor_SMD:C_0402_1005Metric","1",""
"C2525","22uF","Capacitor_SMD:C_0805_2012Metric","1",""
"C2526","22uF","Capacitor_SMD:C_0805_2012Metric","1",""
"C2530","100nF","Capacitor_SMD:C_0402_1005Metric","1",""
"C2600","22uF","Capacitor_SMD:C_0805_2012Metric","1",""
"C2601","100nF","Capacitor_SMD:C_0402_1005Metric","1",""
"C2602","100nF","Capacitor_SMD:C_0402_1005Metric","1",""
"C3200","10nF","Capacitor_SMD:C_0402_1005Metric","1",""
"C3201","1nF","Capacitor_SMD:C_0402_1005Metric","1",""
"C3202","10nF","Capacitor_SMD:C_0402_1005Metric","1",""
"C3203","1nF","Capacitor_SMD:C_0402_1005Metric","1",""
"C3204","4.7uF","Capacitor_SMD:C_0402_1005Metric","1",""
"C3205","100nF","Capacitor_SMD:C_0402_1005Metric","1",""
"C3206","100nF","Capacitor_SMD:C_0402_1005Metric","1",""
"C3207","100nF","Capacitor_SMD:C_0402_1005Metric","1",""
"C3208","100nF","Capacitor_SMD:C_0402_1005Metric","1",""
"C3209","4.7uF","Capacitor_SMD:C_0402_1005Metric","1",""
"C3210","100nF","Capacitor_SMD:C_0402_1005Metric","1",""
"C3211","100nF","Capacitor_SMD:C_0402_1005Metric","1",""
"C3212","100nF","Capacitor_SMD:C_0402_1005Metric","1",""
"C3213","22uF","Capacitor_SMD:C_0603_1608Metric","1",""
"C3214","22uF","Capacitor_SMD:C_0603_1608Metric","1",""
"C3215","22uF","Capacitor_SMD:C_0603_1608Metric","1",""
"C3216","100nF","Capacitor_SMD:C_0402_1005Metric","1",""
"C3217","100nF","Capacitor_SMD:C_0402_1005Metric","1",""
"C3218","100nF","Capacitor_SMD:C_0402_1005Metric","1",""
"C3219","100nF","Capacitor_SMD:C_0402_1005Metric","1",""
"C3220","100nF","Capacitor_SMD:C_0402_1005Metric","1",""
"C3221","100nF","Capacitor_SMD:C_0402_1005Metric","1",""
"C3222","100nF","Capacitor_SMD:C_0402_1005Metric","1",""
"C3223","100nF","Capacitor_SMD:C_0402_1005Metric","1",""
"C3224","100nF","Capacitor_SMD:C_0402_1005Metric","1",""
"C3225","100nF","Capacitor_SMD:C_0402_1005Metric","1",""
"C3226","100nF","Capacitor_SMD:C_0402_1005Metric","1",""
"C3227","100nF","Capacitor_SMD:C_0402_1005Metric","1",""
"C3228","100nF","Capacitor_SMD:C_0402_1005Metric","1",""
"C3229","100nF","Capacitor_SMD:C_0402_1005Metric","1",""
"C3230","1nF","Capacitor_SMD:C_0402_1005Metric","1",""
"C3231","100nF","Capacitor_SMD:C_0402_1005Metric","1",""
"C3232","100nF","Capacitor_SMD:C_0402_1005Metric","1",""
"C3233","1nF","Capacitor_SMD:C_0402_1005Metric","1",""
"C3234","100nF","Capacitor_SMD:C_0402_1005Metric","1",""
"C3235","100nF","Capacitor_SMD:C_0402_1005Metric","1",""
"C3236","100nF","Capacitor_SMD:C_0402_1005Metric","1",""
"C3237","100nF","Capacitor_SMD:C_0402_1005Metric","1",""
"C3238","100nF","Capacitor_SMD:C_0402_1005Metric","1",""
"C3239","100nF","Capacitor_SMD:C_0402_1005Metric","1",""
"C3240","100nF","Capacitor_SMD:C_0402_1005Metric","1",""
"C3241","100nF","Capacitor_SMD:C_0402_1005Metric","1",""
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
## KiCad design USB_2to1_Switch/USB_2to1_Switch.kicad_pcb

File USB_2to1_Switch/README.md:

# USB 2进1出 软件可控切换板 (CH552G + TS3USB221A + 2×TPS22916)

| 文件 | 内容 |
|---|---|
| `USB_2to1_Switch.kicad_pro` | KiCad 项目(用 KiCad 10 打开) |
| `USB_2to1_Switch.kicad_sch` / `_sch.pdf` | 原理图(卡片式,同名全局标签=同网络) |
| `USB_2to1_Switch.kicad_pcb` | PCB(70×55mm,2 层,上下层 GND 铺铜) |
| `USB_2to1_Switch_layout_top.pdf` / `_bottom.pdf` | 上/下层 layout |
| `USB_2to1_Switch_top.png` / `_bottom.png` | 3D 渲染 |
| `fab/` | Gerber、钻孔、位置文件、BOM (**未确认前不要打样**) |
| `REVIEW.md` | 与规格书不符的修正与待确认事项 (**先读这份**) |
| `connectivity.csv` | 每个元件脚位与网络对照 |
| `tools/` | 产生器: `design.py`(唯一的数据来源)、`gen_sch.py`、`build_pcb.py`、`route.py`、`apply_routes.py`、`placement.py` |

重新产生:
1. 改 `tools/design.py`(零件/网络)或 `tools/placement.py`(摆位)
2. `python tools/gen_sch.py`
3. `"C:\Program Files\KiCad\10.0\bin\python.exe" tools/build_pcb.py`
4. `python tools/route.py`(约 1 分钟)
5. `"C:\Program Files\KiCad\10.0\bin\python.exe" tools/apply_routes.py`

`USB_2to1_Switch_placed.*`、`USB_2to1_Switch_nozone.*`、`nz_*.pdf`、`routed.pdf`、`placed_top.pdf`、`drc_placed.json` 是中间产物,可删除。

Parts:
C1, C2, C3, C7, C10, C12, C14, C16, C18: 0.1u; C_0603_1608Metric
C4, C6, C9, C11, C13, C15, C17: 10u; C_0805_2012Metric
C5: 22u; C_0805_2012Metric
ESD1, ESD2, ESD3, ESD4: USBLC6-2SC6; SOT-23-6
F1: PTC 2.5A hold / 5A trip (MF-MSMF250); Fuse_1812_4532Metric
J1, J2: Type-C receptacle (UFP); USB_C_Receptacle_HRO_TYPE-C-31-M-12
J3: USB-A receptacle; USB_A_Molex_67643_Horizontal
J4: Mini-USB-B receptacle; USB_Mini-B_Lumberg_2486_01_Horizontal
J5: ISP 1x6; PinHeader_1x06_P2.54mm_Vertical
LED1: green; LED_0603_1608Metric
LED2: yellow; LED_0603_1608Metric
LED_CMD: blue; LED_0603_1608Metric
LED_PWR: red; LED_0603_1608Metric
Q1, Q2, Q3: 2N7002; SOT-23
R1, R2, R3, R4, R7: 5.1k; R_0603_1608Metric
R5, R6: 1.5k; R_0603_1608Metric
R8, R9, R15, R17: 10k; R_0603_1608Metric
R10, R11, R12, R13, R14: 1k; R_0603_1608Metric
R16: 100; R_0603_1608Metric
SW_BOOT: BOOT; SW_Push_1P1T_XKB_TS-1187A
SW_RST: RST; SW_Push_1P1T_XKB_TS-1187A
TP1, TP10, TP13: TP_GND; TestPoint_Pad_D1.5mm
TP2: TP_+5V; TestPoint_Pad_D1.5mm
TP3: TP_+3V3; TestPoint_Pad_D1.5mm
TP4: TP_V33; TestPoint_Pad_D1.5mm
TP5: TP_RST; TestPoint_Pad_D1.5mm
TP6: TP_CMD; TestPoint_Pad_D1.5mm
TP7: TP_ON1; TestPoint_Pad_D1.5mm
TP8: TP_ON2; TestPoint_Pad_D1.5mm
TP9: TP_S; TestPoint_Pad_D1.5mm
TP11: TP_OUT_VBUS; TestPoint_Pad_D1.5mm
TP12: TP_VSW; TestPoint_Pad_D1.5mm
TP14: TP_VBUS1; TestPoint_Pad_D1.5mm
TP15: TP_VBUS2; TestPoint_Pad_D1.5mm
TVS1, TVS2, TVS3, TVS4: SMAJ5.0A; D_SMA
U1: CH552G; SOIC-16_3.9x9.9mm_P1.27mm
U2: TS3USB221A; Texas_UQFN-10_1.5x2mm_P0.5mm
U3, U4: TPS22916BYFP; TPS22916_YFP_DSBGA-4_0.4mm
U5: AMS1117-3.3; SOT-223-3_TabPin2

Connections:
+3V3: C5.1, C7.1, TP3.1, U2.10 (VCC), U5.2 (VOUT)
+5V: C1.1, C4.1, C6.1, ESD4.5 (VBUS), J4.1 (VBUS), J5.1 (5V), R12.1, R13.1, SW_RST.1, TP2.1, TVS4.1 (K), U1.15 (VCC), U5.3 (VIN)
BOOT: J5.6 (BOOT), R17.1, SW_BOOT.2
CMD: Q3.1 (G), R9.1, TP6.1, U1.2 (P1.4/SCS)
D1N: ESD1.3 (I/O2), ESD1.4 (I/O2), J1.A7 (D-), J1.B7 (D-), U2.2 (1D-)
D1P: ESD1.1 (I/O1), ESD1.6 (I/O1), J1.A6 (D+), J1.B6 (D+), U2.1 (1D+)
D2N: ESD2.3 (I/O2), ESD2.4 (I/O2), J2.A7 (D-), J2.B7 (D-), U2.4 (2D-)
D2P: ESD2.1 (I/O1), ESD2.6 (I/O1), J2.A6 (D+), J2.B6 (D+), U2.3 (2D+)
D3N: ESD3.3 (I/O2), ESD3.4 (I/O2), J3.2 (D-), U2.7 (D-)
D3P: ESD3.1 (I/O1), ESD3.6 (I/O1), J3.3 (D+), U2.8 (D+)
D4N: ESD4.3 (I/O2), ESD4.4 (I/O2), J4.2 (D-), J5.4 (D-), U1.13 (P3.7/UDM)
D4P: ESD4.1 (I/O1), ESD4.6 (I/O1), J4.3 (D+), J5.3 (D+), R17.2, U1.12 (P3.6/UDP)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, ESD1.2 (GND), ESD2.2 (GND), ESD3.2 (GND), ESD4.2 (GND), J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.SH (SHIELD), J2.A1 (GND), J2.A12 (GND), J2.B1 (GND), J2.B12 (GND), J2.SH (SHIELD), J3.4 (GND), J3.SH (SHIELD), J4.5 (GND), J4.SH (SHIELD), J5.2 (GND), LED_PWR.1 (K), Q1.2 (S), Q2.2 (S), Q3.2 (S), R1.2, R2.2, R3.2, R4.2, R5.2, R6.2, R8.2, R9.2, R15.2, TP1.1, TP10.1, TP13.1, TVS1.2 (A), TVS2.2 (A), TVS3.2 (A), TVS4.2 (A), U1.14 (GND), U2.5 (GND), U2.6 (OE), U3.B1 (GND), U4.B1 (GND), U5.1 (GND)
J1_CC1: J1.A5 (CC1), R1.1
J1_CC2: J1.B5 (CC2), R2.1
J2_CC1: J2.A5 (CC1), R3.1
J2_CC2: J2.B5 (CC2), R4.1
LED1_A: LED1.2 (A), R10.2
LED1_K: LED1.1 (K), Q1.3 (D)
LED2_A: LED2.2 (A), R11.2
LED2_K: LED2.1 (K), Q2.3 (D)
LEDC_A: LED_CMD.2 (A), R13.2
LEDC_K: LED_CMD.1 (K), Q3.3 (D)
LEDP_A: LED_PWR.2 (A), R12.2
ON1: Q1.1 (G), R5.1, TP7.1, U1.9 (P1.1), U3.B2 (ON)
ON2: Q2.1 (G), R6.1, TP8.1, U1.4 (P1.6/MISO), U4.B2 (ON)
OUT_VBUS: C17.1, C18.1, ESD3.5 (VBUS), F1.2, J3.1 (VBUS), R10.1, R11.1, TP11.1, TVS3.1 (K)
RST: C3.1, R14.2, R15.1, R16.1, TP5.1, U1.6 (RST)
RSTSW: R14.1, SW_RST.2
RST_J5: J5.5 (RST), R16.2
S: R7.2, R8.1, TP9.1, U2.9 (S)
S_DRV: R7.1, U1.3 (P1.5/MOSI)
V33: C2.1, SW_BOOT.1, TP4.1, U1.16 (V33)
VBUS1: C9.1, C10.1, ESD1.5 (VBUS), J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), TP14.1, TVS1.1 (K), U3.A2 (VIN)
VBUS2: C13.1, C14.1, ESD2.5 (VBUS), J2.A4 (VBUS), J2.A9 (VBUS), J2.B4 (VBUS), J2.B9 (VBUS), TP15.1, TVS2.1 (K), U4.A2 (VIN)
VSW: C11.1, C12.1, C15.1, C16.1, F1.1, TP12.1, U3.A1 (VOUT), U4.A1 (VOUT)

Notes on the sheet:
USB 2-in-1-out software-controlled switch board (CH552G + TS3USB221A + 2x TPS22916)
Design source: USB_2to1_Switch_TypeC_原理图文字版.md - corrected, see REVIEW.md. Same global label = same net.
All GPIO control lines: P1.5->S (divider), P1.1->ON1, P1.6->ON2, P1.4->CMD LED. GND is common, never switched.
